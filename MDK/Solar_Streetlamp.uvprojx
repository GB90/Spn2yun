# Keil uVision project Solar_Streetlamp.uvprojx, settings and files
target Mode (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Solar_Streetlamp +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Bsp\inc;..\CM3\inc;..\STM32F10x_StdPeriph_Lib\inc;..\User\inc;..\Sys\inc;..\Bsp\lcdku
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/src/: main.c stm32f10x_it.c
  group Bsp
    ../Bsp/src/: 24cxx.c adc.c dac.c key.c LCD_160160.c led.c myiic.c remote.c rtc.c stmflash.c timer.c wkup.c
  group STM32F10x_StdPeriph_Lib
    ../STM32F10x_StdPeriph_Lib/: STM32F10x_StdPeriph_Lib_HD.lib
    ../STM32F10x_StdPeriph_Lib/src/: stm32f10x_usart.c
  group CM3
    ../CM3/src/: core_cm3.c system_stm32f10x.c
  group Startup
    ../CM3/startup/: startup_stm32f10x_hd.s
  group Sys
    ../Sys/src/: BIO.c delay.c Display.c iwdg.c sys.c usart.c
